# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HXO01M +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,PRINTF_ENABLE
  c misc: --C99 --diag_suppress=1035
  c include: ..\lib\STM32F4xx_HAL_Driver\Inc;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\lib\STM32_Cryptographic_Library\inc;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\lib\CMSIS\Driver;..\lib\CMSIS\Include;..\lib\STM32_Cryptographic_Library\inc\Common;.\RTE;..\mcu;..\modules\ble;..\power;..\os
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Mcu
    ../mcu/: main.c mcu.c uart.c iap.c internal_flash.c sysTick.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f405xx.s
  group Power
    ../power/: power_mana.c
  group Os
    ../os/: task.c
  group Lib
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sram.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c
  group Ble
    ../modules/ble/: ble.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0
