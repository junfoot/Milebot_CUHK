# Keil uVision project HXO01M.uvprojx, settings and files
target HXO01M (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HXO01M +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,PRINTF_ENABLE,APP_PRJ
  c misc: --C99 --diag_suppress=1035
  c include: ..\lib\STM32F4xx_HAL_Driver\Inc;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\lib\STM32_Cryptographic_Library\inc;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\lib\CMSIS\Driver;..\lib\STM32_Cryptographic_Library\inc\Common;.\RTE;..\mcu;..\system;..\modules\fram;..\modules\MitJoint;..\walk;..\system\abi;..\config;..\controllers;..\modules\wireless_comm;..\modules\sound;..\modules\ble;..\modules\imu;..\lib\CMSIS\Include;..\modules\eeprom;..\modules\wireless
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Mcu
    ../mcu/: adc.c can.c dma.c exti.c main.c mcu.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c uart.c wdg.c startup_stm32f405xx.s sysTick.c tim.c internal_flash.c i2c.c iap.c
  group Walk
    ../: HXO01M.lib
  group Power
    ../power/: power_drv.c power_mana.c
  group System
    ../system/: adc_app.c sys_task.c timer.c
  group Os
    ../os/: task.c
  group Lib
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sram.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c
  group Comm
    ../comm/: comm.c
  group Bat
    ../modules/bat/: bat.c
  group MitJoint
    ../modules/MitJoint/: MitApp.c
    ../: HXO01M.lib
  group Sound
    ../modules/sound/: syn6658.c
  group Ble
    ../modules/ble/: ble.c
  group Imu
    ../modules/imu/: lsm6ds.c
  group DSP_Lib
    ../lib/CMSIS/DSP_Lib/: arm_cortexM4lf_math.lib
  group eeprom
    ../modules/eeprom/: at24c256.c
  group wireless
    ../modules/wireless/: cJSON.c json_app.c normal_lib.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0
